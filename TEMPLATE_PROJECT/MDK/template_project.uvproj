# Keil uVision project template_project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: KEILOUT +hex
  AfterMake: F:\Files\STC16_TEMPLATE_PROJECT\TEMPLATE_PROJECT\MDK\KEIL_SELECT_HEX.bat
  group BOARDFILE
    ../CODES/BOARD/: ADC.c ADC.h BOARD.c BOARD.h COMMON.h DELAY.c DELAY.h EXINT.c EXINT.h GPIO.c GPIO.h HEADFILE.h NVIC.c NVIC.h PWM.c PWM.h STC16Fxx.h TASK.c TASK.h TIMER.c TIMER.h
  group USER
    ../CODES/USERS/: main.c
  group ALGORITHM
    ../CODES/ALGORITHM/: PID.c PID.h EM_Calc.c EM_Calc.h EM_FILTER.c EM_FILTER.h
  group DRIVERFILE
    ../CODES/DRIVER/: EM_SENSOR.c EM_SENSOR.h ENCODE_SENSOR.c ENCODE_SENSOR.h SERVO_MOTOR.c SERVO_MOTOR.h STEP_MOTOR.c STEP_MOTOR.h
  group ZF_lib
    ../CODES/ZF_lib/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h zf_delay.c zf_delay.h zf_gpio.c zf_gpio.h zf_spi.c zf_spi.h
